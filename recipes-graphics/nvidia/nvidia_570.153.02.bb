include nvidia-base.inc
include nvidia-kernel-module.inc
include nvidia-libs.inc

SRC_URI[md5sum] = "dedb9be8a8cb1a893b2a9ff137aceba7"
SRC_URI[sha256sum] = "ebb2e9f1c806db4ce5a9e26fa18fe5add0256779b3d3d447d62c390814dbe9ce"